# Keil uVision project project.uvprojx, settings and files
target Short_Wave (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: short_wave +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\User\adc;..\..\User\rtc;..\..\User\internal_flash;..\..\User\iwdg;..\..\Task;..\..\User\can;..\..\User\firmware_upgrade;..\..\User\STMFLASH;..\..\User\IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Doc
    ../../Doc/: 开发日志.txt 激励器新机器协议指令.txt
  group User
    ../../User/: includes.h FreeRTOSConfig.h main.h main.c my_protocol.c MT2000_protocol.c alarm.c stand_wave_rate.c hard_control.c power.c W5500.c int_char_change.c NTP.c
    ./: Time3_INIT.c
  group Task
    ../../Task/: Task_TH.c Task_Config.h Task_App.c Task_Hardware_Monitor.c Task_Upper_Computer.c Task_MT2000.c Task_Alarm.c
    ./: Task_W5500.c
  group Firmware_Upgrade
    ../../User/firmware_upgrade/: firmware_upgrade.h firmware_upgrade.c
  group BSP
    ../../User/bsp/: bsp.h bsp.c stm32f10x_it.c stm32f10x_assert.c bsp_startup.c bsp_led.c crc16.c
    ../../User/bsp/src/: bsp_uart_fifo.c bsp_tim_pwm.c
    ../../User/adc/: bsp_adc.c
    ../../User/internal_flash/: bsp_internal_flash.c
    ../../User/iwdg/: bsp_iwdg_fire.c
    ../../User/STMFLASH/: stmflash.c
    ../../User/: fifo.c
  group RTC
    ../../User/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_spi.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
